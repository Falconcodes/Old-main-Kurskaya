# IAR project EncodersToArrows.ewp, settings and files
configuration EncodersToArrows (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x4 ST STM32F051x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\STM32F0xx\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EncodersToArrows.hex
  ILINK.IlinkOutputFile: EncodersToArrows.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../Libraries/CMSIS/STM32F0xx/Source/: startup_stm32f0xx.s
  group Libraries
    ../src/: delay.c encoder.c stepper.c stm32f0_discovery.c usart.c xprintf.c
  group STM32F0xx_StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ../: main.c stm32f0xx_it.c system_stm32f0xx.c
