# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STM320518_EVAL; STM32F0XX; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\STM32F0xx\Include; ..\..\..\Libraries\CMSIS\Include; Eval-Board; $PROJ_DIR$; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM0; ..\Common\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.bin
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: FreeRTOSConfig.h main-blinky.c main.c ParTest.c startup_stm32f0xx.s
  group Eval-Board
    Eval-Board/: stm32f0_discovery.c
  group FreeRTOS
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group Libraries/CMSIS
    ../../../Libraries/CMSIS/STM32F0xx/Source/: system_stm32f0xx.c
  group Libraries/StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c
  group Standard-Demo-Tasks
    ../Common/Minimal/: blocktim.c countsem.c dynamic.c recmutex.c
