# IAR project TeslaMainBoard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F0XX; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\STM32F0xx\Include; ..\..\..\Libraries\CMSIS\Include; drivers-board; drivers-i2c; drivers-uart; $PROJ_DIR$; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM0; ..\Common\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: TeslaMainBoard.hex
  ILINK.IlinkOutputFile: TeslaMainBoard.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: CommonConfig.h FreeRTOSConfig.h main-monitor.c main.c startup_stm32f0xx.s
    drivers-board/: hardware_defines.h
  group Board
    drivers-board/: stm32f0_discovery.c stm32f0_tesla_board.c
  group FreeRTOS
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group Libraries/CMSIS
    ../../../Libraries/CMSIS/STM32F0xx/Source/: system_stm32f0xx.c
  group Libraries/I2C
    drivers-i2c/: ds1307.c i2c_driver.c
  group Libraries/StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group Libraries/UART
    drivers-uart/: serial.c xprintf.c
  group Tasks
    tasks-common/: animation.c cabinet.c communication.c graphite.c hightvoltage.c projector.c timemachine.c
